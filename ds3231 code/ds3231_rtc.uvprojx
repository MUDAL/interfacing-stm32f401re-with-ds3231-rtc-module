# Keil uVision project ds3231_rtc.uvprojx, settings and files
target stm32f401re (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ds3231_rtc
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Main Application
    ./: main.c
  group High Layer API
    ./: ds3231.c ds3231.h
  group Low Layer API
    ./: clocks.c clocks.h gpio.c gpio.h i2c.c i2c.h iwdg.c iwdg.h systick.c systick.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
